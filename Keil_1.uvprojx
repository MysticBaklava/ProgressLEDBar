# Keil uVision project Keil_1.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Keil_1 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=2 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\Objects\Keil_1.sct
  group Source Group 1
    ./: main.c bezier.c bezier.h test_scenes.c main.h uart.c uart.h modbus.c modbus.h interrupts.c led_drive.h led_drive.c color_structs.h spi.c spi.h parameters.c serial_flash.c segment_animate.c segment_animate.h content.c
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 6.0.0, Device:Startup 1.0.0
